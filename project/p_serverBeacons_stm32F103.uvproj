# Keil uVision project p_serverBeacons_stm32F103.uvproj, settings and files
target STM32 Simulator (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: p_serverBeacons_stm32F103
  AfterMake: "C:\Users\Administrateur\Desktop\CodeSourcery\Sourcery G++ Lite\bin\arm-none-eabi-size.exe"
  group System Files
    ../system/stm32f103/: startup-gcc.S
  group Drivers
    ../include/drivers/: ADC.h GPIO.h TIMER_1234.H Timer_Systick.h LCD.h
    ../src/drivers/: clock.c usart.c LCD_4bit.c
  group Services
    ../src/services/: s_beaconSignal.c s_serialComm.c
  group Applications
    ../src/applications/: main.c Emission.c Emission.h
    ../include/applications/: global.h
target STM32 Flash (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: p_serverBeacons_stm32F103
